# IAR project mqtt.ewp, settings and files
configuration client (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; DEBUG
  ICCARM.CCIncludePath2: ..\client\; ..\sl\; ..\common\; ..\platform\; ..\include\; ..\..\..\simplelink\; ..\..\..\simplelink\source\; ..\..\..\simplelink\include\; ..\..\..\oslib\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\third_party\FreeRTOS\source\; ..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mqtt.out
configuration client_server (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: ..\client\; ..\sl\; ..\common\; ..\platform\; ..\include\; ..\server\; ..\platform\; ..\..\..\simplelink\; ..\..\..\simplelink\source\; ..\..\..\simplelink\include\; ..\..\..\oslib\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\third_party\FreeRTOS\source\; ..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4
  ICCARM.CCOptLevel: 3
  group (top)
    ../platform/: cc31xx_sl_net.c cc3200_platform.c
    ../server/: client_mgmt.c server_core.c server_pkts.c server_plug.c server_util.c
    ../client/: mqtt_client.c
    ../common/: mqtt_common.c
    ../sl/: sl_mqtt_client.c sl_mqtt_server.c
